# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,STM32F2XX
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F2xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM322xG_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config;../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../Utilities/Third_Party/FreeRTOS/Source/include;../../../../Libraries/STM32F2x7_ETH_Driver/inc;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/lwip;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/netif;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/ipv4;../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F2x7;../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F2x7/FreeRTOS/
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Libraries/STemWin_V532/OS
    ../Config/: GUI_X_FreeRTOS.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: timers.c list.c tasks.c croutine.c queue.c
  group Libraries/STemWin_V532/Config
    ../Config/: LCDConf_stm322xg_eval.c GUIConf_stm322xg_eval.c
  group Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_hash_md5.c stm32f2xx_i2c.c stm32f2xx_flash.c stm32f2xx_syscfg.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_dbgmcu.c stm32f2xx_wwdg.c stm32f2xx_pwr.c stm32f2xx_crc.c stm32f2xx_adc.c stm32f2xx_dcmi.c stm32f2xx_rtc.c stm32f2xx_can.c stm32f2xx_tim.c stm32f2xx_hash.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_fsmc.c stm32f2xx_cryp_tdes.c stm32f2xx_cryp.c stm32f2xx_iwdg.c stm32f2xx_cryp_des.c stm32f2xx_sdio.c stm32f2xx_usart.c misc.c stm32f2xx_hash_sha1.c stm32f2xx_exti.c stm32f2xx_spi.c stm32f2xx_cryp_aes.c stm32f2xx_rng.c
  group Utilities/LwIP/Core/IPv4
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: icmp.c ip_addr.c inet_chksum.c inet.c ip.c autoip.c igmp.c ip_frag.c
  group Utilities/LwIP/Netif
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group Appli/Demo
    ../Demo/: GUIDEMO_ImageFlow.c GUIDEMO_Vnc.c GUIDEMO_Speedometer.c GUIDEMO_VScreen.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Listview.c GUIDEMO_BarGraph.c GUIDEMO_Resource.c GUIDEMO_Conf.c GUIDEMO_WashingMachine.c GUIDEMO_AntialiasedText.c GUIDEMO_Bitmap.c GUIDEMO_Fading.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_Cursor.c GUIDEMO_IconView.c GUIDEMO_Treeview.c GUIDEMO_RadialMenu.c GUIDEMO_Skinning.c GUIDEMO_Graph.c GUIDEMO.c GUIDEMO_Intro.c GUIDEMO_ColorBar.c GUIDEMO_Automotive.c GUIDEMO_TransparentDialog.c
  group Appli/MDK-ARM
    ./: startup_stm32f2xx.s
  group Libraries/STM322xG-EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_ioe.c stm322xg_eval.c stm322xg_eval_fsmc_sram.c stm322xg_eval_lcd.c
  group Utilities/LwIP/Core
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: lwip_timers.c sys.c dns.c udp.c def.c tcp.c memp.c init.c mem.c pbuf.c dhcp.c stats.c tcp_out.c netif.c tcp_in.c raw.c
  group Libraries/STM32F2x7_ETH_Driver
    ../../../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group Utilities/LwIP/Api
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: sockets.c netdb.c api_lib.c err.c api_msg.c tcpip.c netbuf.c netifapi.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Portable/ARM_CM3
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port_cm3.c
  group Appli/User
    ../User/: stm32xxx_it.c system_stm32f2xx.c stm32f2x7_eth_bsp.c GUI_VNC_X_StartServer.c main.c netconf.c bsp.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM3_OS_Keil.lib
  group Doc
    ../: readme.txt readme.txt
software components: CMSIS:CORE 4.3.0

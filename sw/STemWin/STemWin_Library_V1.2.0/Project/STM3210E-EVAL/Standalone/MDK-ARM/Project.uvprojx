# Keil uVision project Project.uvprojx, settings and files
target STM3210E-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_XL
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3210E_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Appli/User
    ../User/: stm32xxx_it.c system_stm32f10x.c bsp.c main.c
  group Libraries/STemWin_V532/Config
    ../../../../Libraries/STemWinLibrary532/OS/: GUI_X.c
    ../Config/: LCDConf_stm3210e_eval.c GUIConf_stm3210e_eval.c
  group Appli/MDK-ARM
    ./: startup_stm32f10x_xl.s
  group Appli/Demo
    ../Demo/: GUIDEMO_Speedometer.c GUIDEMO_VScreen.c GUIDEMO_AntialiasedText.c GUIDEMO_ZoomAndRotate.c GUIDEMO_BarGraph.c GUIDEMO.c GUIDEMO_Graph.c GUIDEMO_Skinning.c GUIDEMO_Resource.c GUIDEMO_Intro.c GUIDEMO_RadialMenu.c GUIDEMO_TransparentDialog.c GUIDEMO_ColorBar.c GUIDEMO_IconView.c GUIDEMO_Listview.c GUIDEMO_Treeview.c GUIDEMO_Fading.c GUIDEMO_Bitmap.c GUIDEMO_Automotive.c GUIDEMO_Speed.c GUIDEMO_WashingMachine.c GUIDEMO_Start.c GUIDEMO_Conf.c GUIDEMO_ImageFlow.c GUIDEMO_Cursor.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM3_Keil.lib
  group Libraries/STM3210E-EVAL
    ../../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_fsmc_sram.c stm3210e_eval_lcd.c stm3210e_eval.c
  group Libraries/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_dac.c stm32f10x_tim.c stm32f10x_crc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_exti.c misc.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_i2c.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0

# Keil uVision project Project.uvprojx, settings and files
target STM32303C-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM32303C_EVAL,STM32F303xC
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F30x_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F30x/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM32303C_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config;../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Utilities/Third_Party/FreeRTOS/Source/include
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Libraries/STemWin_V532/Config
    ../Config/: GUIConf_stm32303c_eval.c LCDConf_stm32303c_eval.c
  group Appli/MDK-ARM
    ./: startup_stm32f30x.s
  group Appli/Demo
    ../Demo/: GUIDEMO_ColorBar.c GUIDEMO_Intro.c GUIDEMO_Speed.c GUIDEMO_ImageFlow.c GUIDEMO_Treeview.c GUIDEMO_Listview.c GUIDEMO_ZoomAndRotate.c GUIDEMO_IconView.c GUIDEMO.c GUIDEMO_VScreen.c GUIDEMO_Speedometer.c GUIDEMO_Bitmap.c GUIDEMO_BarGraph.c GUIDEMO_AntialiasedText.c GUIDEMO_WashingMachine.c GUIDEMO_TransparentDialog.c GUIDEMO_Fading.c GUIDEMO_RadialMenu.c GUIDEMO_Cursor.c GUIDEMO_Conf.c GUIDEMO_Graph.c GUIDEMO_Skinning.c GUIDEMO_Resource.c GUIDEMO_Automotive.c GUIDEMO_Start.c
  group Libraries/STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dbgmcu.c stm32f30x_i2c.c stm32f30x_rtc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_can.c stm32f30x_iwdg.c stm32f30x_crc.c stm32f30x_comp.c stm32f30x_wwdg.c stm32f30x_spi.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_dac.c stm32f30x_gpio.c stm32f30x_syscfg.c stm32f30x_usart.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: tasks.c croutine.c list.c timers.c queue.c
  group Libraries/STemWin_V532/OS
    ../Config/: GUI_X_FreeRTOS.c
  group Utilities/FreeRTOS/Portable/ARM_CM4F
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port_cm4.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_OS_Keil.lib
  group Appli/User
    ../User/: stm32xxx_it.c bsp.c main.c system_stm32f30x.c
  group Libraries/STM32303C-EVAL
    ../../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval_lcd.c stm32303c_eval.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0

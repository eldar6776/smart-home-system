# Keil uVision project RS485_RelayExpander.uvprojx, settings and files
target RS485_RelayExpander (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: rexp +hex
  BeforeMake: Run\fwbuild.bat
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=Out\rexp.bin Exe\rexp.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x6, CARD_STACKER, APPLICATION, USE_WATCHDOG
  c include: ../Inc;../../Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Inc;../../Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Inc/Legacy;../../Drivers/STM32F0xx/CMSIS/Device/ST/STM32F0xx/Include;../../Drivers/STM32F0xx/CMSIS/Include;..\..\Common;..\..\Middlewares\TinyFrame;..\..\Middlewares\LuxNET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    Asm/: startup_stm32f030x6.s
  group Application/User/Core
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
    ../../Middlewares/TinyFrame/: TinyFrame.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.4.0

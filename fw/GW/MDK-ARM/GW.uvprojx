# Keil uVision project GW.uvprojx, settings and files
target GW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gw +hex
  BeforeMake: Run\fwbuild.bat
  AfterMake: Run\gw.bat
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER, USE_LCD, HOTEL_CONTROLLER, APPLICATION, USE_WATCHDOG
  c include: ..\Driver\CMSIS\Device\ST\STM32F4xx\Inc;..\Driver\STM32F4xx_StdPeriph_Driver\inc;..\Middlewares\lwip141\src\include;..\Middlewares\lwip141\src\include\ipv4;..\Middlewares\lwip141\src\include\lwip;..\Middlewares\lwip141\src\include\netif;..\Middlewares\lwip141\port\arch;..\Middlewares\lwip141\port\Standalone;..\Middlewares\lwip141\src\netif;..\Middlewares\TFTP_Server;..\Middlewares\FATFS;..\Middlewares\HTTP_Server;..\Middlewares\STemWinLibrary532\inc;..\Middlewares\NetBIOS_Server;..\Middlewares\Config;..\..\Common;..\Inc;..\..\Middlewares\TinyFrame;..\..\Middlewares\LuxNET
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Run\gw.sct
  group Libraries/CMSIS
    ../Driver/CMSIS/Device/ST/STM32F4xx/Src/: system_stm32f4xx.c
    ./Asm/: startup_stm32f429_439xx.s
  group Libraries/StdPeriph_Driver
    ../Driver/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_iwdg.c stm32f4xx_dcmi.c
  group Middlewares/STemWin/Lib
    ../Middlewares/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group Middlewares/STemWin/Config
    ../Middlewares/Config/: GUIDRV_stm32f429i.c GUI_X_Touch.c GUIConf.c GUI_X.c
  group Libraries/lwip141
    ../Middlewares/lwip141/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/lwip141/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Middlewares/lwip141/src/netif/: etharp.c slipif.c
    ../Middlewares/lwip141/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Middlewares/lwip141/port/Standalone/: ethernetif.c
  group DEVICE_Driver
    ../Src/: rtc.c delay.c stm32f429i_lcd.c stm32f429i_sdram.c sdio_sd.c buzzer.c uart.c gpio.c fs5206.c spi_flash.c i2cee.c
  group NetBIOS_Server
    ../Middlewares/NetBIOS_Server/: netbios.c
  group TFTP_Server
    ../Middlewares/TFTP_Server/: netconf.c fatfs_drv.c tftpserver.c tftputils.c sys_arch.c
  group HTTP_Server
    ../Middlewares/HTTP_Server/: fs.c httpd.c httpd_cgi_ssi.c
  group ETH_Driver
    ../Src/: stm32f4x7_eth.c eth_bsp.c
  group GUI_Display
    ../Src/: display.c usd_ok.c usd_error.c net_error.c net_connected.c
  group FATFS
    ../Middlewares/FATFS/: ff.c
  group Application
    ../Src/: stm32f4xx_it.c main.c
    ../../Middlewares/TinyFrame/: TinyFrame.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.4.0

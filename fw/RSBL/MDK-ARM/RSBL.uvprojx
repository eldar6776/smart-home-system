# Keil uVision project RSBL.uvprojx, settings and files
target RSBL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rsbl +hex
  BeforeMake: Run\fwbuild.bat
  AfterMake: Run\rsbl.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F746xx, ROOM_THERMOSTAT, BOOTLOADER
  c include: ..\..\Drivers\STM32F7xx\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\STM32F7xx\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\STM32F7xx\BSP\STM32F746;..\..\Drivers\STM32F7xx\BSP\Components;..\..\Middlewares\ST\STemWin\inc;..\..\Common;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Run\rsbl.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/HARDWARE
    ../../Drivers/STM32F7xx/BSP/STM32F746/: stm32746g_qspi.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_iwdg.c
  group Application/MDK-ARM
    Asm/: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c main.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.4.0

# Keil uVision project IRC0816.uvprojx, settings and files
target IRC0816 (6130001::V6.13.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IRC0816 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB, ROOM_CONTROLLER, APPLICATION, USE_DEBUGGER
  c include: ..\Inc;..\..\Common;..\..\Drivers\STM32F1xx\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx\STM32F1xx_HAL_Driver\Inc;..\..\Middlewares\TinyFrame;..\..\Middlewares\LuxNET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Application/MDK-ARM
    Asm/: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c rs485.c pwm.c anin.c dio.c main.c
    ../../Middlewares/TinyFrame/: TinyFrame.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.4.0
